<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AD7708\AD7708.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC12\ADC12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DAC12\DAC12.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA\DMA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Flash\Flash.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Key\Key.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lcd12864\lcd12864.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Multiplier\Multiplier.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Nixietube\Nixietube.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Printf\Printf.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Spi\Spi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SupplyVoltageSupervisor\SVS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TimerPwm\TimerPwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\UART.ewp</path>
  </project>
  <batchBuild/>
</workspace>


